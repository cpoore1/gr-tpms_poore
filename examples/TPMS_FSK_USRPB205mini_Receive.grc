options:
  parameters:
    generate_options: qt_gui
    id: TPMS_FSK_USRPB205mini_Receive
    output_language: python
    title: TPMS_FSK_USRPB205mini_Receive
  states: {}

blocks:
- name: rx_usrp_antenna
  id: variable
  parameters:
    value: '"TX/RX"'
  states: {}
- name: rx_usrp_channel
  id: variable
  parameters:
    value: '"A:A"'
  states: {}
- name: rx_usrp_frequency
  id: variable
  parameters:
    value: 315e6
  states: {}
- name: rx_usrp_gain
  id: variable
  parameters:
    value: '70'
  states: {state: disabled}
- name: rx_usrp_gain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '90'
    value: '70'
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: sample_rate/(2*math.pi*80000/8.0)
  states: {}
- name: blocks_burst_tagger_0
  id: blocks_burst_tagger
  parameters:
    false_key: burst
    false_value: 'False'
    true_key: burst
    true_value: 'True'
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '20'
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/user8/FISSURE/Custom_Blocks/maint-3.8/gr-tpms_poore/examples/prius_front_left_bad5_cropped.bin
    repeat: 'True'
    type: complex
  states: {state: disabled}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: '1'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '20'
    type: float
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.004'
    init: '0'
    low: '0.004'
  states: {}
- name: blocks_threshold_ff_0_0
  id: blocks_threshold_ff
  parameters:
    high: '-4'
    init: '0'
    low: '-4'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: sample_rate
    type: complex
  states: {state: disabled}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: 20*[0.05]
    type: fff
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: 4*[0.25]
    type: fff
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '40000'
    srate: '1'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '5000'
    srate: '1'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '40000'
    srate: '1'
    type: float
  states: {state: disabled}
- name: tpms_poore_decoder_0
  id: tpms_poore_decoder
  parameters: {}
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: rx_usrp_antenna
    center_freq0: rx_usrp_frequency
    dc_offs_enb0: '""'
    dev_args: '""'
    gain0: rx_usrp_gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: sample_rate
    sd_spec0: rx_usrp_channel
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', fir_filter_xxx_0_0, '0']
- [blocks_burst_tagger_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_burst_tagger_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_squared_0, '0', fir_filter_xxx_0, '0']
- [blocks_delay_0, '0', blocks_burst_tagger_0, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_float_to_short_0, '0', blocks_burst_tagger_0, '1']
- [blocks_keep_one_in_n_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_keep_one_in_n_0, '0', tpms_poore_decoder_0, '0']
- [blocks_threshold_ff_0, '0', blocks_float_to_short_0, '0']
- [blocks_threshold_ff_0_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_throttle_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_throttle_0, '0', blocks_delay_0, '0']
- [fir_filter_xxx_0, '0', blocks_threshold_ff_0, '0']
- [fir_filter_xxx_0_0, '0', blocks_threshold_ff_0_0, '0']
- [fir_filter_xxx_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [tpms_poore_decoder_0, out, blocks_message_debug_0, print]
- [uhd_usrp_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [uhd_usrp_source_0, '0', blocks_delay_0, '0']

metadata:
  file_format: 1
